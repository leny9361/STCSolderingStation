# Keil uVision project STCSolderingStation.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STCSolderingStation +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51
    ./src/: adc.c arduboy.c delay.c EC11.c i2c.c main.c oled.c Timer0.c uart.c PID_v1.c e2prom.c temp.c tip.c t12timer.c
  group ins
    ./src/: t12timer.h tip.h e2prom.h PID_v1.h i2c.h oledfont.h Timer0.h uart.h oled.h delay.h EC11.h config.h arduboy.h adc.h sysconst.h temp.h
